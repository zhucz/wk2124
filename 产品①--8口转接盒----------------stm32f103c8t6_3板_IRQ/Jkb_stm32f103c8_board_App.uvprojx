# Keil uVision project Jkb_stm32f103c8_board_App.uvprojx, settings and files
target APP (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Jkb_stm32f103c8_board_App +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\USER\include;.\USER\BSP\inc;.\USER\HW_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group BSP
    ./USER/BSP/: bsp_gpio.c bsp_spi.c bsp_systick.c bsp_timer2.c bsp_usart2.c bsp_printf.c bsp_flash.c
  group HW_Driver
    ./USER/HW_Driver/: wk2124_uart0.c wk2124_usart1.c wk2124_pca1.c wk2124_pca0.c wk2124_epca2.c wk2124_epca1.c wk2124_epca0.c wk2124_usart0.c wk2124s.c wk2124s2.c
  group include
    ./USER/include/: board.h cf8051.h crc8.h linkerlist.h myService.h newList.h os_struct.h s3c44b0x.h soft_timer.h special_buff.h timerOut.h
  group app
    ./USER/app/: cf8051.c crc8.c myService.c newList.c s3c44b0x.c soft_timer.c timerOut.c main.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
